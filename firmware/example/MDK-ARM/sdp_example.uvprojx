# Keil uVision project sdp_example.uvprojx, settings and files
target v3 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F078VB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: build
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F078xx,USE_FULL_LL_DRIVER
  c misc: --C99
  c include: ../Inc;                                                                 ../Drivers/STM32F0xx_HAL_Driver/Inc;                                                                 ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;                                                                 ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;                                                                 ../Drivers/CMSIS/Include; ../../../../../../Inc; ../../../../../../Drivers/STM32F0xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32F0xx/Include; ../../../../../../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group user_libs
    ../Src/: sdp_user.c sdp.c ring_buffer.c stm32xx_hal_liquid_crystal.c stm32xx_hal_delay_us.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_dma.c stm32f0xx_hal_adc.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_i2c.c stm32f0xx_hal_cortex.c stm32f0xx_hal_tim.c stm32f0xx_hal_flash.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_spi.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_adc_ex.c stm32f0xx_ll_usart.c stm32f0xx_ll_gpio.c stm32f0xx_ll_dma.c stm32f0xx_ll_utils.c stm32f0xx_ll_exti.c stm32f0xx_ll_rcc.c stm32f0xx_ll_crc.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Application/MDK-ARM
    ./: startup_stm32f078xx.s
  group Application/User
    ../Src/: main.c stm32f0xx_it.c usart.c crc.c gpio.c stm32f0xx_hal_msp.c
software components: CMSIS:CORE 4.1.0
